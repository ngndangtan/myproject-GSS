# Keil uVision project gGimbal.uvproj, settings and files
target gGimbal (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: gStabi_r1_3_4 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\;..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\Libraries\mavlink\include\common;..\..\..\Libraries\mavlink\include;..\..\..\Libraries\mavlink\v1.0\gremsyBGC;..\..\..\Libraries\mavlink\v1.0\common;..\..\..\Libraries\mavlink\v1.0
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../: main.c system_stm32f10x.c usart1.c startup.c timer.c gMavlinkV1_0.c eeprom.c globalData.c attitude.c motor.c sensorCalib.c sbus.c mpu6000.c radio.c gpio.c gMath.c adc.c interrupt.c ublox_gps.c
  group StdPeriph_Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_gpio.c misc.c stm32f10x_tim.c stm32f10x_flash.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_iwdg.c stm32f10x_spi.c stm32f10x_adc.c
  group CMSIS
    ../../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group Start up
    ../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
